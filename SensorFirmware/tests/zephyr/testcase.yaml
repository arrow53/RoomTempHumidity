## SensorFirmware/tests/zephyr/testcase.yaml
```yaml
tests:
  room_sensor.core:
    tags: [room_sensor]
    platform_allow: [native_sim, qemu_cortex_m3]
    integration_platforms: [native_sim]
```
